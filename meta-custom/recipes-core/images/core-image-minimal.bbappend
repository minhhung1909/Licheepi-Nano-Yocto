IMAGE_INSTALL_append = " ppp ppp-simcom"
