FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://sim_module.cfg"
